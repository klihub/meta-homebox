# python3-lang lacks a dependency (inspect) on python3-enum.
RDEPENDS_${PN}-lang += "python3-enum"
